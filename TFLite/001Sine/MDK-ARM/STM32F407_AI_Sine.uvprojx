# Keil uVision project STM32F407_AI_Sine.uvprojx, settings and files
target STM32F407_AI_Sine (6120000::V6.12::.\ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F407_AI_Sine +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../tensorflowlite;../../tensorflowlite/third_party;../../tensorflowlite/third_party/flatbuffers/include;../../tensorflowlite/third_party/gemmlowp;../../tensorflowlite/third_party/ruy
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group tensorflow
    ../../tensorflowlite/tensorflow/core/public/: version.h
    ../../tensorflowlite/tensorflow/lite/: string_type.h string_util.h type_to_tflitetype.h
    ../../tensorflowlite/tensorflow/lite/c/: builtin_op_data.h common.c common.h
    ../../tensorflowlite/tensorflow/lite/core/api/: error_reporter.cc error_reporter.h flatbuffer_conversions.cc flatbuffer_conversions.h op_resolver.cc op_resolver.h tensor_utils.cc tensor_utils.h
    ../../tensorflowlite/tensorflow/lite/kernels/: kernel_util.cc kernel_util.h op_macros.h padding.h
    ../../tensorflowlite/tensorflow/lite/kernels/internal/: compatibility.h cppmath.h quantization_util.cc quantization_util.h strided_slice_logic.h tensor.h tensor_ctypes.h types.h
    ../../tensorflowlite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
    ../../tensorflowlite/tensorflow/lite/kernels/internal/reference/: add.h arg_min_max.h binary_function.h ceil.h comparisons.h concatenation.h conv.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h floor.h fully_connected.h l2normalization.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_nearest_neighbor.h round.h softmax.h strided_slice.h sub.h
    ../../tensorflowlite/tensorflow/lite/kernels/internal/reference/integer_ops/: depthwise_conv.h
    ../../tensorflowlite/tensorflow/lite/micro/: debug_log.h memory_helpers.cc memory_helpers.h micro_allocator.cc micro_allocator.h micro_error_reporter.cc micro_error_reporter.h micro_interpreter.cc micro_interpreter.h micro_mutable_op_resolver.h micro_optional_debug_tools.cc micro_optional_debug_tools.h micro_string.cc micro_string.h micro_time.cc micro_time.h micro_utils.cc micro_utils.h simple_memory_allocator.cc simple_memory_allocator.h test_helpers.cc test_helpers.h
    ../../tensorflowlite/tensorflow/lite/micro/kernels/: activation_utils.h activations.cc add.cc all_ops_resolver.cc all_ops_resolver.h arg_min_max.cc ceil.cc circular_buffer.cc comparisons.cc concatenation.cc conv.cc depthwise_conv.cc dequantize.cc elementwise.cc floor.cc fully_connected.cc l2norm.cc logical.cc logistic.cc maximum_minimum.cc micro_ops.h mul.cc neg.cc pack.cc pad.cc pooling.cc prelu.cc quantize.cc reduce.cc reshape.cc resize_nearest_neighbor.cc round.cc softmax.cc split.cc strided_slice.cc sub.cc svdf.cc unpack.cc
    ../../tensorflowlite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc greedy_memory_planner.h linear_memory_planner.cc linear_memory_planner.h memory_planner.h
    ../../tensorflowlite/tensorflow/lite/micro/testing/: micro_benchmark.h micro_test.h test_utils.cc test_utils.h
    ../../tensorflowlite/tensorflow/lite/schema/: schema_generated.h
  group Application/User
    ../Src/: gpio.c crc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.cpp sine_model.cpp
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.3.0
